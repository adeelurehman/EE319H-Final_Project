# Keil uVision project Lab10_C++.uvprojx, settings and files
target Lab 10 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab10_C++
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c misc: --cpp11
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup_TM4C123.s main.cpp DAC.cpp PLL.cpp random.cpp ST7735.cpp SlidePot.cpp Sound.cpp Timer0.cpp Timer1.cpp UART.cpp FIFO.cpp Grid.cpp Barrier.cpp Player.cpp Sprites.cpp Gem.cpp Button.cpp Systick.cpp Controls.cpp
  group Include
    ./: Barrier.h Button.h DAC.h Drawable.h FIFO.h Gem.h Grid.h Images.h Physics.h Player.h PLL.h random.h SlidePot.h Sound.h Sprites.h ST7735.h Timer0.h Timer1.h UART.h Systick.h Controls.h
software components: CMSIS:CORE 5.0.2
